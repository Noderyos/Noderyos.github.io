options:
  parameters:
    author: Noderyos
    description: NOAA-2 HRPT Decoder
    generate_options: qt_gui
    id: ITOS
    output_language: python
    title: ITOS HRPT
  states: {}

blocks:
- name: samp_rate_mhz
  id: variable
  parameters:
    value: '4'
  states: {}
- name: width
  id: variable
  parameters:
    value: '13107'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: math.pi/2
  states: {}
- name: analog_quadrature_demod_cf_1_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: math.pi/2
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: itos.f32
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-99e3'
    sample_rate: 1e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_mhz*1e6
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: NOAA-2.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '32768'
    grid: 'True'
    name: Subcarrier
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e6
    fc: '0'
    fftsize: '32768'
    name: RF FFT
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    ncols: width
    nrows: '256'
    samp_rate: '60000'
    type: float
    zmax: '5'
    zmin: '-5'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate_mhz
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '6'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rf
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: if
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: af
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rf
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: if
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: af
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_float_to_complex_1_0, '0']
- [analog_quadrature_demod_cf_1_0, '0', virtual_sink_2, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_1_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_1_0, '0', virtual_sink_1, '0']
- [blocks_freqshift_cc_0_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [rational_resampler_xxx_1_0, '0', analog_quadrature_demod_cf_1_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0_0, '0']
- [virtual_source_1, '0', blocks_freqshift_cc_0_0, '0']
- [virtual_source_2, '0', blocks_file_sink_0, '0']
- [virtual_source_2, '0', qtgui_time_raster_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
